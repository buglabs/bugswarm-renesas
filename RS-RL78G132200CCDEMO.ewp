# IAR project RS-RL78G132200CCDEMO.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 512
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: user_include\; Glyph\; user_src\; applilet3_src\; wlan\; wifi_uart_hal\; swarm_libs\
  XLINK.XclFile: applilet3_src\md_lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: user_include\; Glyph\; user_src\; applilet3_src\; wlan\; wifi_uart_hal\
  group applilet_src
    applilet3_src/: CG_macrodriver.h CG_main.c CG_port.c CG_port.h CG_port_user.c CG_serial.c CG_serial.h CG_serial_user.c CG_system.c CG_system.h CG_system_user.c CG_systeminit.c CG_userdefine.h PinoutDef.h Preamble.h
  group Glyph
    Glyph/: glyph.c glyph_api.h glyph_cfg.h glyph_register.c glyph_types.h
  group Glyph/Drivers
    Glyph/Drivers/: ST7579_LCD.c ST7579_LCD.h YRDKRL78_LCD.c YRDKRL78_LCD.h
  group Glyph/Fonts
    Glyph/Fonts/: font_x5x7.c
  group swarm_libs
    swarm_libs/: swarm.c swarm.h
  group user_src
    user_src/: app_wifi_init.c lcd.c lcd.h RDKRL78_spi.c RDKRL78_spi.h rsi_demo_app.c rsi_demo_app.h
  group wifi_api
    wlan/: rsi_at_command_processor.h rsi_data_types.h rsi_global.h rsi_lib_api.c rsi_lib_at_cmd_processor.c rsi_lib_boot.c rsi_lib_init.c rsi_uart_api.h
  group wifi_uart_hal
    wifi_uart_hal/: rsi_hal.h rsi_hal_api.h rsi_hal_init.c rsi_hal_timers.c rsi_hal_uart.c
